# Keil uVision project template-keil-stm32f030f4.uvprojx, settings and files
target iSensor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030,STM32F030x6, USE_STDPERIPH_DRIVER,
  c include: {% for module in modules %}..\{{ module.folder }};{% endfor %}..\HAL;..\STM32F0xx_StdPeriph_Driver;..\STM32F0xx_StdPeriph_Driver\inc;..\STM32F0xx_StdPeriph_Driver\src;..\STM32F0xx_StdPeriph_Driver\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group {{ module.folder }}
    ../{{ module.folder }}/: {{file.fileName}}
  group HAL
    ../HAL/: _jdy08.c _jdy08.h _onewire_pin.c _onewire_pin.h _pins.h _reedsw.c _reedsw.h _rtc.c _rtc.h _uart.c _uart.h _water.c _water.h hal.c hal.h halInterface.h
  group SPL
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c
    ../STM32F0xx_StdPeriph_Driver/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
