# Keil uVision project template-keil-stm32f091rb.uvprojx, settings and files
target iSensor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F091RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: {% for module in modules %}..\{{ module['folder'] }};{% endfor %}
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group {{ module['folder'] }}
    ../{{ module['folder'] }}/: {{file['fileName']}}
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
